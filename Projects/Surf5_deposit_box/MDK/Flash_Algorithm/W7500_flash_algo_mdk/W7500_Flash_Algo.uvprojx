# Keil uVision project W7500_Flash_Algo.uvprojx, settings and files
target W7500_128 (5060422::V5.06 update 4 (build 422)::ARMCC)
  device: ARMCM0 ARM
  pack: ARM.Cortex_DFP.1.1.0
  cpu: IRAM(0x20000000,0x00020000) IROM(0x00000000,0x00040000) CPUTYPE("Cortex-M0") CLOCK(12000000) ESEL ELITTLE
  output: W7500_128 +hex
  AfterMake: cmd.exe /C copy "%L" "..\@L.FLM"
  AfterMake: fromelf --bin -o "$L@L.bin" "#L"
  c flags: Optim=3
  memory RVCT4: ROM 0x0 size 0x40000
  memory RVCT9: RAM 0x20000000 size 0x20000
  scatter file: .\Target.lin
  link misc: --diag_suppress L6305
  group Program Functions
    ./: FlashPrg.c
  group Device Description
    ./: FlashDev.c
software components: CMSIS:CORE 6.1.0
