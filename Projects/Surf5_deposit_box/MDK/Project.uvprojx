# Keil uVision project Project.uvprojx, settings and files
target W7500x (5060960::V5.06 update 7 (build 960)::.\ARM_Compiler_5.06u7)
  device: ARMCM0 ARM
  pack: ARM.Cortex_DFP.1.1.0
  cpu: IRAM(0x20000000,0x00020000) IROM(0x00000000,0x00040000) CPUTYPE("Cortex-M0") CLOCK(12000000) ESEL ELITTLE
  output: W7500x +hex
  AfterMake: fromelf --bin -o "$L@L.bin" "#L"
  c flags: Optim=4 v6Lang=1 v6LangP=1
  c define: CORTEX_M0 USE_STDPERIPH_DRIVER
  c include: ..\..\..\Libraries\W7500x_stdPeriph_Driver\inc;..\..\..\Libraries\CMSIS\Include;..\..\..\Libraries\CMSIS\Device\WIZnet\W7500\Include;..\..\..\src;..\..\..\Libraries\ioLibrary\Ethernet;..\..\..\Libraries\ioLibrary\Internet\DHCP;..\..\..\Libraries\ioLibrary\Internet\DNS;..\..\..\Libraries\ioLibrary\Application\loopback
  memory RVCT4: ROM 0x0 size 0x20000
  memory RVCT9: RAM 0x20000000 size 0x4000
  group MDK-ARM
    ../../../Libraries/CMSIS/Device/WIZnet/W7500/Source/ARM/: startup_w7500x.s
  group CMSIS
    ../../../Libraries/CMSIS/Device/WIZnet/W7500/Source/: system_w7500x.c
  group StdPeriph_Driver
    ../../../Libraries/W7500x_StdPeriph_Driver/src/: w7500x_adc.c w7500x_crg.c w7500x_dualtimer.c w7500x_exti.c w7500x_gpio.c w7500x_pwm.c w7500x_rng.c w7500x_ssp.c w7500x_uart.c w7500x_wdt.c w7500x_wztoe.c w7500x_miim.c w7500x_misc.c w7500x_rtc.c w7500x_flash.c i2c.c
  group ioLibrary
    ../../../Libraries/ioLibrary/Application/loopback/: loopback.c
    ../../../Libraries/ioLibrary/Ethernet/: socket.c wizchip_conf.c
    ../../../Libraries/ioLibrary/Internet/DHCP/: dhcp.c
    ../../../Libraries/ioLibrary/Internet/DNS/: dns.c
  group User
    ../../../src/: main.c retarget.c w7500x_it.c
software components: CMSIS:CORE 6.1.0
